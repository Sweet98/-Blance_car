# IAR project fire_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\app; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\flash; ..\..\src\drivers\lcd; ..\..\src\drivers\motor; ..\..\src\drivers\coder; ..\..\src\drivers\ccd; ..\..\src\drivers\infrared; ..\..\src\drivers\balance; ..\..\src\drivers\uart_send; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\speed; ..\..\src\drivers\dma; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\ccd; ..\..\src\drivers\direction; ..\..\src\drivers\kalman; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\timer; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\build; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\uCOS-II\App; ..\..\src\uCOS-II\App\CFG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\app; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\build; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\uCOS-II\App; ..\..\src\uCOS-II\App\CFG
  ICCARM.CCOptLevel: 3
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group common/app
    ../../src/app/: isr.c main.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/AT24C02/: AT24C02.c
    ../../src/drivers/balance/: balance.c
    ../../src/drivers/ccd/: ccd.c
    ../../src/drivers/coder/: coder.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/direction/: direction.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/Flash/: flash.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/i2c/: i2c.c
    ../../src/drivers/infrared/: infrared.c
    ../../src/drivers/kalman/: kalman.c
    ../../src/drivers/lcd/: lcd.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/motor/: motor.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/speed/: speed.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/uart_send/: uart_send.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/app/: include.h isr.h
    ../../src/platforms/: k60_fire.h
  group uCOS-II
    ../../src/LIB/CMSIS/: iar_cortexM4l_math.a
  group uCOS-II/App
    ../../src/uCOS-II/App/: app.c app_hooks.c BSP.c
  group uCOS-II/App/CFG
    ../../src/uCOS-II/App/CFG/: app_cfg.h os_cfg.h
  group uCOS-II/Ports
    ../../src/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    ../../src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
